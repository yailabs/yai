## target_fs/kernel/Kconfig
```kconfig
menu "YAI Kernel"

config YAI_KERNEL
    bool "Build YAI kernel substrate"
    default y

endmenu
```
